# Keil uVision project MotorControl_FOC.uvprojx, settings and files
target MC_FOC_M15x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SC32M156C7 SinOneMicroelectronics
  pack: SinOne.SC32M1xxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SOC_FOC_SDK_V1_0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FW\Inc;..\Device\src;..\MCI\Inc;..\User\Inc;..\Board\Inc;..\User\HeadFiles;..\CMSIS;..\Device\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Config
    ../FW/Inc/: cfg_motor.h cfg_ctrl.h cfg_board.h fw_config.h
  group App
    ../FW/Src/: main.c supervisor.c ctrl_globals.c diag.c
  group Control
    ../FW/Src/: startup.c speed_ctrl.c mtpa_fw.c identify.c
  group Observer
    ../FW/Src/: est.c flux_obs.c flux_pll.c
  group FOC_Core
    ../FW/Src/: foc_core.c mathx.c
  group HAL_Board
    ../FW/Src/: hal_sc32r602.c
    ../Board/Src/: SC_Init.c
    ../Board/Inc/: Hardware_config.h
  group Device
    ../Device/src/: sc32m1xxx_adc.c sc32m1xxx_btm.c sc32m1xxx_can.c sc32m1xxx_cmp.c sc32m1xxx_crc.c sc32m1xxx_dac.c sc32m1xxx_dma.c sc32m1xxx_epwm.c sc32m1xxx_gpio.c sc32m1xxx_iap.c sc32m1xxx_int.c sc32m1xxx_mr.c sc32m1xxx_op.c sc32m1xxx_option.c sc32m1xxx_pcap.c sc32m1xxx_pwr.c sc32m1xxx_qep.c sc32m1xxx_rcc.c sc32m1xxx_spi.c sc32m1xxx_spi1_twi1.c sc32m1xxx_temper.c sc32m1xxx_tim.c sc32m1xxx_twi.c sc32m1xxx_uart.c sc32m1xxx_vref.c sc32m1xxx_wdt.c
  group Startup
    ../CMSIS/: startup_sc32M156xx .s system_sc32m15xx.c
  group MCI
    ../MCI/Src/: SOC_MCI_2R_V102.lib
